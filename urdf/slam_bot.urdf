Commit message: second update

File: urdf/slam_bot.urdf (robot description, URDF)
Before this commit: robot slam_bot, 8 links, 7 joints
Joints:
- joint Wheel_Front_Right_mount: axis 0 -1 0 -> 0 1 0
- joint Wheel_Rear_Left_mount: axis 0 -1 0 -> 0 1 0
